## drivers/devcon/Kconfig
```kconfig
config DEVCON
	tristate "Developer Console"
	depends on DRM && TTY && INPUT
	depends on FONT_SUPPORT && FONT_8x16
	help
	  Foobar.

	  If unsure, say N.
```
